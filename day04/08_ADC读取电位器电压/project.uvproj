# Keil uVision project project.uvproj, settings and files
target ADC (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Code
    ./: Delay.c GPIO.c GPIO_Isr.c main.c NVIC.c Switch.h ADC.c ADC_Isr.c UART.c UART_Isr.c
