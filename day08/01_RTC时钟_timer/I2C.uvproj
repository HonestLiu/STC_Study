# Keil uVision project I2C.uvproj, settings and files
target RTC_TIMER (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: I2C +hex
  c flags: Optimize=8 SizeSpeed=1
  group Code
    ./: Delay.c GPIO.c GPIO_Isr.c I2C.c I2C_Isr.c main.c NVIC.c UART.c UART_Isr.c PCF8563.c Exti.c
