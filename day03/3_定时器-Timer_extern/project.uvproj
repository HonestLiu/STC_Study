# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c GPIO.c main.c NVIC.c Timer.c Timer_Isr.c UART.c UART_Isr.c
