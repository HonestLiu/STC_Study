# Keil uVision project project.uvproj, settings and files
target RTX51 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Lib
  group OS
    ./OS/: Conf_tny.A51 RTX51TNY.LIB
  group User
    ./User/: main.c
  group Lib
    ./Lib/: GPIO.c ADC.c ADC_Isr.c UART.c UART_Isr.c NVIC.c STC8H_PWM.c
  group Drive
    ./Drive/: Light.c Key.c battery.c Buzzer.c Ultrasonic .c Track.c Motors.c
