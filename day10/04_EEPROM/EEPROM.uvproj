# Keil uVision project EEPROM.uvproj, settings and files
target EEPROM (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: EEPROM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Delay.c EEPROM.c GPIO.c GPIO_Isr.c main.c NVIC.c UART.c UART_Isr.c
